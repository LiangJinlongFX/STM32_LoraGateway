# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\BSP_USER\LED;..\CORE;..\Common;..\STM32f4_LIB\inc;..\SYSTEM;..\MQTT_Protocol\mqtt;..\Utils;..\MQTT_Protocol\ONENET
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f40_41xxx.s
  group SYSTEM
    ../SYSTEM/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group BSP_USER
    ../BSP_USER/LED/: led.c
  group Common
    ../Common/: delay.c sys.c usart1.c usart2.c
  group STM32F4_LIB
    ../STM32f4_LIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_dma.c
  group Protocol
    ../MQTT_Protocol/mqtt/: mqtt.c mqtt_buffer.c
    ../MQTT_Protocol/ONENET/: onenet_mqtt.c
  group Utils
    ../Utils/: cJSON.c utils.c
software components: CMSIS:CORE 5.0.2, RTOS:device drivers 2.1.2, RTOS:kernel 2.1.2, RTOS:shell 2.1.2
